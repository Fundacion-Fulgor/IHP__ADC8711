v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
B 2 1330 -620 2130 -220 {flags=graph
y1=-1.6590605
y2=-0.34506045
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-4.4017606e-07
x2=-3.2941851e-07
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
color="7 6 4 8"
node="inp
out
out_a
in_a"
linewidth_mult=0.5
divx=20
hilight_wave=-1}
B 2 6930 -1250 7730 -850 {flags=graph
y2=1.5
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-3.3878304e-09
x2=4.0243869e-08
divx=5
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0
hilight_wave=0
color=10
node=S1[5]
y1=-0.4}
N -510 -910 -510 -900 {
lab=IO_vdd}
N -370 -910 -370 -900 {
lab=IO_iovdd}
N -440 -910 -440 -900 {
lab=IO_vss}
N -140 -510 570 -510 {lab=IO_vdd}
N -190 -420 -130 -420 {lab=IO_vdd}
N -190 -460 -140 -460 {lab=IO_vdd}
N -190 -470 -150 -470 {lab=IO_vdd}
N -490 -440 -430 -440 {lab=in_a}
N -490 -460 -490 -440 {lab=in_a}
N -530 -440 -490 -440 {lab=in_a}
N -190 -410 -120 -410 {lab=IO_vdd}
N -490 -360 -430 -360 {lab=in_b}
N -490 -380 -490 -360 {lab=in_b}
N -530 -360 -490 -360 {lab=in_b}
N -190 -390 -150 -390 {lab=IO_vdd}
N -190 -380 -140 -380 {lab=IO_vdd}
N -190 -340 -130 -340 {lab=IO_vdd}
N -130 -420 -130 -340 {lab=IO_vdd}
N -190 -330 -120 -330 {lab=IO_vdd}
N -120 -410 -120 -330 {lab=IO_vdd}
N -190 -310 -150 -310 {lab=IO_vdd}
N -150 -390 -150 -310 {lab=IO_vdd}
N -190 -300 -140 -300 {lab=IO_vdd}
N -140 -380 -140 -300 {lab=IO_vdd}
N -190 -260 -130 -260 {lab=IO_vdd}
N -130 -340 -130 -260 {lab=IO_vdd}
N -190 -250 -120 -250 {lab=IO_vdd}
N -120 -330 -120 -250 {lab=IO_vdd}
N -490 -280 -430 -280 {lab=in_c}
N -490 -300 -490 -280 {lab=in_c}
N -530 -280 -490 -280 {lab=in_c}
N -190 -360 20 -360 {lab=STOP}
N -130 -500 560 -500 {lab=IO_vdd}
N 570 -240 570 110 {lab=IO_vdd}
N 580 -250 580 120 {lab=IO_vdd}
N 370 90 550 90 {lab=IO_vdd}
N -190 -280 -100 -280 {lab=CTRL[0]}
N 580 -250 610 -250 {lab=IO_vdd}
N 570 -240 610 -240 {lab=IO_vdd}
N 560 -200 610 -200 {lab=IO_vdd}
N 550 -190 610 -190 {lab=IO_vdd}
N 850 -220 910 -220 {lab=out_a}
N 910 -240 910 -220 {lab=out_a}
N 910 -220 950 -220 {lab=out_a}
N -490 -120 -430 -120 {lab=in_e}
N -490 -140 -490 -120 {lab=in_e}
N -530 -120 -490 -120 {lab=in_e}
N -190 -150 -150 -150 {lab=IO_vdd}
N -190 -140 -140 -140 {lab=IO_vdd}
N -120 -490 550 -490 {lab=IO_vdd}
N -150 -470 -150 -390 {lab=IO_vdd}
N -140 -460 -140 -380 {lab=IO_vdd}
N -490 -200 -430 -200 {lab=in_d}
N -490 -220 -490 -200 {lab=in_d}
N -530 -200 -490 -200 {lab=in_d}
N -150 -230 -150 -150 {lab=IO_vdd}
N -140 -220 -140 -140 {lab=IO_vdd}
N -140 -510 -140 -460 {lab=IO_vdd}
N -150 -520 -150 -470 {lab=IO_vdd}
N -130 -500 -130 -420 {lab=IO_vdd}
N -120 -490 -120 -410 {lab=IO_vdd}
N 550 -490 550 -190 {lab=IO_vdd}
N 560 -500 560 -200 {lab=IO_vdd}
N 570 -510 570 -240 {lab=IO_vdd}
N 580 -520 580 -250 {lab=IO_vdd}
N -490 -40 -430 -40 {lab=in_f}
N -490 -60 -490 -40 {lab=in_f}
N -530 -40 -490 -40 {lab=in_f}
N -190 -70 -150 -70 {lab=IO_vdd}
N -190 -60 -140 -60 {lab=IO_vdd}
N -190 -40 40 -40 {lab=DECLK}
N -150 -150 -150 -70 {lab=IO_vdd}
N -140 -140 -140 -60 {lab=IO_vdd}
N -190 -440 40 -440 {lab=START}
N -190 -230 -150 -230 {lab=IO_vdd}
N -150 -310 -150 -230 {lab=IO_vdd}
N -190 -220 -140 -220 {lab=IO_vdd}
N -140 -300 -140 -220 {lab=IO_vdd}
N -190 -200 -100 -200 {lab=CTRL[1]}
N -190 -180 -130 -180 {lab=IO_vdd}
N -130 -260 -130 -180 {lab=IO_vdd}
N -190 -170 -120 -170 {lab=IO_vdd}
N -120 -250 -120 -170 {lab=IO_vdd}
N 240 -520 580 -520 {lab=IO_vdd}
N -190 -100 -130 -100 {lab=IO_vdd}
N -130 -180 -130 -100 {lab=IO_vdd}
N -190 -90 -120 -90 {lab=IO_vdd}
N -120 -170 -120 -90 {lab=IO_vdd}
N -190 -10 -120 -10 {lab=IO_vdd}
N -120 -90 -120 -10 {lab=IO_vdd}
N -190 -20 -130 -20 {lab=IO_vdd}
N -130 -100 -130 -20 {lab=IO_vdd}
N 160 -840 160 -790 {lab=VSS}
N 160 -1030 160 -990 {lab=in_b}
N 160 -930 160 -900 {lab=#net1}
N 440 -840 440 -790 {lab=VSS}
N 440 -950 440 -900 {lab=in_c}
N -200 -840 -200 -810 {lab=GND}
N -200 -940 -200 -900 {lab=VSS}
N -120 -940 -120 -900 {lab=in_a}
N -120 -840 -120 -790 {lab=VSS}
N -120 -640 -120 -590 {lab=VSS}
N -120 -750 -120 -700 {lab=in_e}
N 240 -520 240 -280 {lab=IO_vdd}
N -150 -520 240 -520 {lab=IO_vdd}
N 160 -640 160 -590 {lab=VSS}
N 160 -750 160 -700 {lab=in_f}
N 40 -240 120 -240 {lab=START}
N 20 -220 120 -220 {lab=STOP}
N -190 -120 -100 -120 {lab=CTRL[2]}
N 60 -200 120 -200 {lab=CTRL[2:0]}
N 460 -220 610 -220 {lab=OUT}
N -150 120 70 120 {lab=IO_vdd}
N 80 110 80 150 {lab=IO_vdd}
N 120 100 120 150 {lab=IO_vdd}
N 130 90 130 150 {lab=IO_vdd}
N 70 120 70 150 {lab=IO_vdd}
N 100 470 100 490 {lab=IO_vdd}
N -120 90 130 90 {lab=IO_vdd}
N 150 470 180 470 {lab=IO_vdd}
N 180 470 180 490 {lab=IO_vdd}
N 120 100 200 100 {lab=IO_vdd}
N 150 120 150 150 {lab=IO_vdd}
N 100 120 150 120 {lab=IO_vdd}
N 160 110 160 150 {lab=IO_vdd}
N 80 110 160 110 {lab=IO_vdd}
N 200 100 200 150 {lab=IO_vdd}
N 210 90 210 150 {lab=IO_vdd}
N 130 90 210 90 {lab=IO_vdd}
N 230 120 230 150 {lab=IO_vdd}
N 150 120 230 120 {lab=IO_vdd}
N -490 40 -430 40 {lab=in_g}
N -490 20 -490 40 {lab=in_g}
N -530 40 -490 40 {lab=in_g}
N -190 10 -150 10 {lab=IO_vdd}
N -190 20 -140 20 {lab=IO_vdd}
N -190 60 -130 60 {lab=IO_vdd}
N -190 70 -120 70 {lab=IO_vdd}
N -150 -70 -150 10 {lab=IO_vdd}
N -140 -60 -140 20 {lab=IO_vdd}
N -130 -20 -130 60 {lab=IO_vdd}
N -120 -10 -120 70 {lab=IO_vdd}
N 40 -160 120 -160 {lab=DECLK}
N -190 40 60 40 {lab=RESET}
N 60 -140 120 -140 {lab=RESET}
N 240 120 240 150 {lab=IO_vdd}
N 180 110 240 110 {lab=IO_vdd}
N 310 120 310 150 {lab=IO_vdd}
N 320 110 320 150 {lab=IO_vdd}
N 280 120 280 150 {lab=IO_vdd}
N 200 100 280 100 {lab=IO_vdd}
N 290 120 290 150 {lab=IO_vdd}
N 260 90 290 90 {lab=IO_vdd}
N 360 100 360 150 {lab=IO_vdd}
N 340 100 360 100 {lab=IO_vdd}
N 370 90 370 150 {lab=IO_vdd}
N 260 470 260 490 {lab=IO_vdd}
N 290 120 310 120 {lab=IO_vdd}
N 70 470 100 470 {lab=IO_vdd}
N 230 470 260 470 {lab=IO_vdd}
N 340 470 340 490 {lab=IO_vdd}
N 300 470 340 470 {lab=IO_vdd}
N 100 120 100 470 {lab=IO_vdd}
N 70 120 100 120 {lab=IO_vdd}
N 180 110 180 470 {lab=IO_vdd}
N 160 110 180 110 {lab=IO_vdd}
N 260 90 260 470 {lab=IO_vdd}
N 210 90 260 90 {lab=IO_vdd}
N 340 100 340 470 {lab=IO_vdd}
N 280 100 340 100 {lab=IO_vdd}
N 240 120 280 120 {lab=IO_vdd}
N 280 100 280 120 {lab=IO_vdd}
N 290 90 290 110 {lab=IO_vdd}
N 240 110 290 110 {lab=IO_vdd}
N 290 90 370 90 {lab=IO_vdd}
N 280 120 290 120 {lab=IO_vdd}
N 290 110 290 120 {lab=IO_vdd}
N 290 110 320 110 {lab=IO_vdd}
N 360 -190 460 -190 {lab=OUT}
N 60 -140 60 40 {lab=RESET}
N 310 120 580 120 {lab=IO_vdd}
N 320 110 570 110 {lab=IO_vdd}
N 240 110 240 120 {lab=IO_vdd}
N 550 -190 550 90 {lab=IO_vdd}
N 560 -200 560 100 {lab=IO_vdd}
N -140 20 -140 110 {lab=IO_vdd}
N -130 60 -130 100 {lab=IO_vdd}
N -120 70 -120 90 {lab=IO_vdd}
N 360 100 560 100 {lab=IO_vdd}
N 230 120 240 120 {lab=IO_vdd}
N -150 10 -150 120 {lab=IO_vdd}
N -140 110 80 110 {lab=IO_vdd}
N -130 100 120 100 {lab=IO_vdd}
N 240 -100 240 110 {lab=IO_vdd}
N 460 -220 460 -190 {lab=OUT}
N 40 -160 40 -40 {lab=DECLK}
N 40 -440 40 -240 {lab=START}
N 20 -360 20 -220 {lab=STOP}
N -300 -910 -300 -900 {lab=IO_iovss}
N 440 -640 440 -590 {lab=VSS}
N 440 -750 440 -700 {lab=in_g}
N 4870 -580 4870 -550 {lab=VSS}
N 4640 -200 4640 -170 {lab=VSS}
N 4870 -680 4870 -640 {lab=RESET_PAD}
N 4640 -300 4640 -260 {lab=DECLK}
N 4760 -490 4760 -460 {lab=VSS}
N 4640 -580 4640 -550 {lab=VSS}
N 4760 -680 4760 -640 {lab=STOP_PAD}
N 4640 -680 4640 -640 {lab=START_PAD}
N 4760 -580 4760 -550 {lab=#net1}
N 6010 -680 6010 -660 {lab=IO_vdd}
N 6450 -680 6450 -660 {lab=IO_vdd}
N 6010 -480 6010 -460 {lab=IO_vss}
N 6450 -480 6450 -460 {lab=IO_vss}
N 5570 -410 5570 -390 {lab=IO_vdd}
N 6010 -410 6010 -390 {lab=IO_vdd}
N 5570 -210 5570 -190 {lab=IO_vss}
N 6010 -210 6010 -190 {lab=IO_vss}
N 6130 -320 6170 -320 {lab=S2[6:0]}
N 6130 -280 6170 -280 {lab=COUT2}
N 6570 -590 6630 -590 {lab=D0[5:0]}
N 6570 -570 6610 -570 {lab=D1[5:0]}
N 6570 -550 6590 -550 {lab=D2[5:0]}
N 6290 -540 6330 -540 {lab=DECLK}
N 6310 -520 6330 -520 {lab=RESET}
N 6130 -590 6190 -590 {lab=C0_B[5:0]}
N 6130 -570 6210 -570 {lab=C1_B[5:0]}
N 6130 -550 6230 -550 {lab=C2_B[5:0]}
N 5870 -520 5890 -520 {lab=DECLK}
N 5850 -550 5890 -550 {lab=K2}
N 5830 -570 5890 -570 {lab=K1}
N 5810 -590 5890 -590 {lab=K0}
N 5410 -350 5450 -350 {lab=D0[5:0]}
N 5410 -300 5450 -300 {lab=D1[5:0]}
N 5410 -250 5450 -250 {lab=VSS}
N 6190 -620 6190 -590 {lab=C0_B[5:0]}
N 6190 -620 6330 -620 {lab=C0_B[5:0]}
N 6210 -600 6210 -570 {lab=C1_B[5:0]}
N 6210 -600 6330 -600 {lab=C1_B[5:0]}
N 6230 -580 6230 -550 {lab=C2_B[5:0]}
N 6230 -580 6330 -580 {lab=C2_B[5:0]}
N 5690 -320 5710 -320 {lab=S1[5:0]}
N 5690 -280 5710 -280 {lab=COUT1}
N 5870 -250 5890 -250 {lab=VSS}
N 5870 -300 5890 -300 {lab=VSS,D2[5:0]}
N 5870 -350 5890 -350 {lab=COUT1,S1[5:0]}
N 6450 -410 6450 -390 {lab=IO_vdd}
N 6450 -210 6450 -190 {lab=IO_vss}
N 6570 -300 6610 -300 {lab=ADDER[7:0]}
N 6310 -260 6330 -260 {lab=RESET}
N 6290 -300 6330 -300 {lab=DECLK2}
N 6290 -340 6330 -340 {lab=COUT2,S2[6:0]}
N 6040 -960 6080 -960 {lab=START}
N 6040 -920 6080 -920 {lab=STOP}
N 6150 -1020 6150 -990 {lab=IO_vdd}
N 6150 -890 6150 -860 {lab=IO_vss}
N 6350 -1030 6350 -1000 {lab=IO_vdd}
N 6220 -960 6290 -960 {lab=EN}
N 6350 -760 6350 -730 {lab=IO_vss}
N 6450 -760 6450 -730 {lab=IN0}
N 6570 -760 6570 -730 {lab=IN1}
N 6690 -760 6690 -730 {lab=IN2}
N 5570 -480 5570 -450 {lab=IO_vss}
N 5690 -610 5720 -610 {lab=K0}
N 5690 -570 5720 -570 {lab=K1}
N 5690 -530 5720 -530 {lab=K2}
N 5420 -610 5450 -610 {lab=IN0}
N 5420 -570 5450 -570 {lab=IN1}
N 5420 -530 5450 -530 {lab=IN2}
N 5570 -690 5570 -660 {lab=IO_vdd}
N 4720 -200 4720 -170 {lab=VSS}
N 4720 -300 4720 -260 {lab=DECLK2}
N 6270 590 6420 590 {lab=IO_vdd}
N 6260 580 6430 580 {lab=IO_vss}
N 6240 570 6440 570 {lab=IO_vdd}
N 6210 560 6450 560 {lab=IO_vdd}
N 6270 1210 6430 1210 {lab=IO_vss}
N 5920 640 5980 640 {lab=IO_vss}
N 5920 600 5970 600 {lab=IO_vdd}
N 5920 590 5960 590 {lab=IO_vdd}
N 5960 590 5960 650 {lab=IO_vdd}
N 5980 580 6180 580 {lab=IO_vss}
N 5620 620 5680 620 {lab=START_PAD}
N 5620 600 5620 620 {lab=START_PAD}
N 5580 620 5620 620 {lab=START_PAD}
N 5960 650 5990 650 {lab=IO_vdd}
N 5980 1210 6190 1210 {lab=IO_vss}
N 4780 -960 4780 -950 {
lab=IO_vdd}
N 4840 -960 4840 -950 {
lab=IO_iovdd}
N 4700 -960 4700 -950 {
lab=IO_vss}
N 4640 -960 4640 -950 {
lab=IO_iovss}
N 4720 -810 4740 -810 {lab=GND}
N 4740 -810 4740 -800 {lab=GND}
N 4640 -810 4660 -810 {lab=sub!}
N 4640 -810 4640 -800 {lab=sub!}
N 6220 1570 6250 1570 {lab=IO_vss}
N 6130 1570 6170 1570 {lab=IO_vdd}
N 6140 1230 6140 1270 {lab=IO_vdd}
N 6150 1220 6150 1270 {lab=IO_vdd}
N 6190 1210 6190 1270 {lab=IO_vss}
N 6200 1200 6200 1270 {lab=IO_vdd}
N 6220 1230 6220 1270 {lab=IO_vdd}
N 6230 1220 6230 1270 {lab=IO_vdd}
N 6270 1210 6270 1270 {lab=IO_vss}
N 6280 1200 6280 1270 {lab=IO_vdd}
N 6250 1210 6250 1570 {lab=IO_vss}
N 6250 1570 6250 1610 {lab=IO_vss}
N 6170 1570 6170 1610 {lab=IO_vdd}
N 6170 1200 6170 1570 {lab=IO_vdd}
N 6170 1200 6200 1200 {lab=IO_vdd}
N 6140 1230 6220 1230 {lab=IO_vdd}
N 6150 1220 6230 1220 {lab=IO_vdd}
N 6250 1210 6270 1210 {lab=IO_vss}
N 6200 1200 6280 1200 {lab=IO_vdd}
N 6190 1210 6250 1210 {lab=IO_vss}
N 6220 1230 6450 1230 {lab=IO_vdd}
N 6230 1220 6440 1220 {lab=IO_vdd}
N 6280 1200 6420 1200 {lab=IO_vdd}
N 5970 1220 6150 1220 {lab=IO_vdd}
N 5960 1230 6140 1230 {lab=IO_vdd}
N 5990 1200 6170 1200 {lab=IO_vdd}
N 6190 530 6190 590 {lab=IO_vdd}
N 6180 530 6180 580 {lab=IO_vss}
N 6140 530 6140 570 {lab=IO_vdd}
N 6130 530 6130 560 {lab=IO_vdd}
N 6270 530 6270 590 {lab=IO_vdd}
N 6260 530 6260 580 {lab=IO_vss}
N 6220 530 6220 570 {lab=IO_vdd}
N 6210 530 6210 560 {lab=IO_vdd}
N 6160 230 6160 290 {lab=IO_vdd}
N 6240 230 6240 290 {lab=IO_vdd}
N 6130 290 6160 290 {lab=IO_vdd}
N 6160 290 6160 560 {lab=IO_vdd}
N 6200 290 6240 290 {lab=IO_vdd}
N 6240 290 6240 570 {lab=IO_vdd}
N 5990 590 6190 590 {lab=IO_vdd}
N 5970 570 6140 570 {lab=IO_vdd}
N 5960 560 6130 560 {lab=IO_vdd}
N 6190 590 6270 590 {lab=IO_vdd}
N 6180 580 6260 580 {lab=IO_vss}
N 6140 570 6220 570 {lab=IO_vdd}
N 6160 560 6210 560 {lab=IO_vdd}
N 6130 560 6160 560 {lab=IO_vdd}
N 6220 570 6240 570 {lab=IO_vdd}
N 5920 650 5960 650 {lab=IO_vdd}
N 5980 580 5980 640 {lab=IO_vss}
N 5970 570 5970 600 {lab=IO_vdd}
N 5960 560 5960 590 {lab=IO_vdd}
N 5990 590 5990 650 {lab=IO_vdd}
N 5920 620 6040 620 {lab=START}
N 6430 680 6490 680 {lab=IO_vss}
N 6440 720 6490 720 {lab=IO_vdd}
N 6450 730 6490 730 {lab=IO_vdd}
N 6730 700 6790 700 {lab=in_a}
N 6790 700 6790 720 {lab=in_a}
N 6790 700 6830 700 {lab=in_a}
N 6420 670 6490 670 {lab=IO_vdd}
N 6370 700 6490 700 {lab=ADDER[1]}
N 5920 720 5980 720 {lab=IO_vss}
N 5920 680 5970 680 {lab=IO_vdd}
N 5920 670 5960 670 {lab=IO_vdd}
N 5620 700 5680 700 {lab=STOP_PAD}
N 5620 680 5620 700 {lab=STOP_PAD}
N 5580 700 5620 700 {lab=STOP_PAD}
N 5920 730 5990 730 {lab=IO_vdd}
N 5920 700 6040 700 {lab=STOP}
N 5980 640 5980 720 {lab=IO_vss}
N 5970 600 5970 680 {lab=IO_vdd}
N 5960 650 5960 670 {lab=IO_vdd}
N 5990 650 5990 730 {lab=IO_vdd}
N 5920 800 5980 800 {lab=IO_vss}
N 5920 760 5970 760 {lab=IO_vdd}
N 5920 750 5960 750 {lab=IO_vdd}
N 5620 780 5680 780 {lab=RESET_PAD}
N 5620 760 5620 780 {lab=RESET_PAD}
N 5580 780 5620 780 {lab=RESET_PAD}
N 5920 810 5990 810 {lab=IO_vdd}
N 5920 780 6040 780 {lab=RESET}
N 5980 720 5980 800 {lab=IO_vss}
N 5970 680 5970 760 {lab=IO_vdd}
N 5960 670 5960 750 {lab=IO_vdd}
N 5990 730 5990 810 {lab=IO_vdd}
N 6430 600 6490 600 {lab=IO_vss}
N 6440 640 6490 640 {lab=IO_vdd}
N 6450 650 6490 650 {lab=IO_vdd}
N 6730 620 6790 620 {lab=in_a}
N 6790 620 6790 640 {lab=in_a}
N 6790 620 6830 620 {lab=in_a}
N 6420 590 6490 590 {lab=IO_vdd}
N 6370 620 6490 620 {lab=ADDER[0]}
N 6430 760 6490 760 {lab=IO_vss}
N 6440 800 6490 800 {lab=IO_vdd}
N 6450 810 6490 810 {lab=IO_vdd}
N 6730 780 6790 780 {lab=in_a}
N 6790 780 6790 800 {lab=in_a}
N 6790 780 6830 780 {lab=in_a}
N 6420 750 6490 750 {lab=IO_vdd}
N 6370 780 6490 780 {lab=ADDER[2]}
N 6430 840 6490 840 {lab=IO_vss}
N 6440 880 6490 880 {lab=IO_vdd}
N 6450 890 6490 890 {lab=IO_vdd}
N 6730 860 6790 860 {lab=in_a}
N 6790 860 6790 880 {lab=in_a}
N 6790 860 6830 860 {lab=in_a}
N 6420 830 6490 830 {lab=IO_vdd}
N 6370 860 6490 860 {lab=ADDER[3]}
N 6430 920 6490 920 {lab=IO_vss}
N 6450 960 6490 960 {lab=IO_vdd}
N 6450 970 6490 970 {lab=IO_vdd}
N 6730 940 6790 940 {lab=in_a}
N 6790 940 6790 960 {lab=in_a}
N 6790 940 6830 940 {lab=in_a}
N 6420 910 6490 910 {lab=IO_vdd}
N 6370 940 6490 940 {lab=ADDER[4]}
N 6430 600 6430 680 {lab=IO_vss}
N 6440 640 6440 720 {lab=IO_vdd}
N 6450 650 6450 730 {lab=IO_vdd}
N 6420 590 6420 670 {lab=IO_vdd}
N 6430 580 6430 600 {lab=IO_vss}
N 6440 570 6440 640 {lab=IO_vdd}
N 6450 560 6450 650 {lab=IO_vdd}
N 6430 680 6430 760 {lab=IO_vss}
N 6440 720 6440 800 {lab=IO_vdd}
N 6450 730 6450 810 {lab=IO_vdd}
N 6420 670 6420 750 {lab=IO_vdd}
N 6430 760 6430 840 {lab=IO_vss}
N 6440 800 6440 880 {lab=IO_vdd}
N 6450 810 6450 890 {lab=IO_vdd}
N 6420 750 6420 830 {lab=IO_vdd}
N 6430 840 6430 920 {lab=IO_vss}
N 6440 880 6440 960 {lab=IO_vdd}
N 6450 960 6450 970 {lab=IO_vdd}
N 6420 830 6420 910 {lab=IO_vdd}
N 6430 1080 6490 1080 {lab=IO_vss}
N 6440 1120 6490 1120 {lab=IO_vdd}
N 6450 1130 6490 1130 {lab=IO_vdd}
N 6730 1100 6790 1100 {lab=in_a}
N 6790 1100 6790 1120 {lab=in_a}
N 6790 1100 6830 1100 {lab=in_a}
N 6420 1070 6490 1070 {lab=IO_vdd}
N 6370 1100 6490 1100 {lab=ADDER[6]}
N 6430 1000 6490 1000 {lab=IO_vss}
N 6440 1040 6490 1040 {lab=IO_vdd}
N 6450 1050 6490 1050 {lab=IO_vdd}
N 6730 1020 6790 1020 {lab=in_a}
N 6790 1020 6790 1040 {lab=in_a}
N 6790 1020 6830 1020 {lab=in_a}
N 6420 990 6490 990 {lab=IO_vdd}
N 6370 1020 6490 1020 {lab=ADDER[5]}
N 6430 1160 6490 1160 {lab=IO_vss}
N 6440 1200 6490 1200 {lab=IO_vdd}
N 6450 1210 6490 1210 {lab=IO_vdd}
N 6730 1180 6790 1180 {lab=in_a}
N 6790 1180 6790 1200 {lab=in_a}
N 6790 1180 6830 1180 {lab=in_a}
N 6420 1150 6490 1150 {lab=IO_vdd}
N 6370 1180 6490 1180 {lab=ADDER[7]}
N 6430 1000 6430 1080 {lab=IO_vss}
N 6440 1040 6440 1120 {lab=IO_vdd}
N 6450 1050 6450 1130 {lab=IO_vdd}
N 6420 990 6420 1070 {lab=IO_vdd}
N 6450 970 6450 1050 {lab=IO_vdd}
N 6430 1080 6430 1160 {lab=IO_vss}
N 6440 1120 6440 1200 {lab=IO_vdd}
N 6450 1130 6450 1210 {lab=IO_vdd}
N 6420 1070 6420 1150 {lab=IO_vdd}
N 6420 910 6420 990 {lab=IO_vdd}
N 6430 920 6430 1000 {lab=IO_vss}
N 6440 960 6440 1040 {lab=IO_vdd}
N 6450 890 6450 960 {lab=IO_vdd}
N 6440 960 6450 960 {lab=IO_vdd}
N 6430 1160 6430 1210 {lab=IO_vss}
N 5980 800 5980 1210 {lab=IO_vss}
N 6450 1210 6450 1230 {lab=IO_vdd}
N 6440 1200 6440 1220 {lab=IO_vdd}
N 6420 1150 6420 1200 {lab=IO_vdd}
N 5970 760 5970 1220 {lab=IO_vdd}
N 5960 750 5960 1230 {lab=IO_vdd}
N 5990 810 5990 1200 {lab=IO_vdd}
C {vsource.sym} -510 -870 0 0 {name=V1 value=1.2}
C {gnd.sym} -510 -840 0 0 {name=l3 lab=GND}
C {lab_pin.sym} -510 -910 1 0 {name=p7 sig_type=std_logic lab=IO_vdd}
C {vsource.sym} -370 -870 0 0 {name=V3 value=3.3
}
C {gnd.sym} -370 -840 0 0 {name=l4 lab=GND}
C {lab_pin.sym} -370 -910 1 0 {name=p8 sig_type=std_logic lab=IO_iovdd}
C {vsource.sym} -440 -870 0 0 {name=V2 value=0 savecurrent=false}
C {gnd.sym} -440 -840 0 0 {name=l5 lab=GND}
C {lab_pin.sym} -440 -910 1 0 {name=p9 sig_type=std_logic lab=IO_vss}
C {vsource.sym} -300 -870 0 0 {name=V4 value=0 savecurrent=false}
C {gnd.sym} -300 -840 0 0 {name=l6 lab=GND}
C {lab_pin.sym} -300 -910 1 0 {name=p10 sig_type=std_logic lab=IO_iovss}
C {devices/code_shown.sym} -1380 -450 0 0 {name=MODEL only_toplevel=true
format="tcleval( @value )"
value="
.lib cornerMOSlv.lib mos_tt
.lib cornerMOShv.lib mos_tt
.lib cornerRES.lib res_typ
.include diodes.lib
.include sg13g2_bondpad.lib
"}
C {devices/code_shown.sym} -1370 -260 0 0 {name=NGSPICE only_toplevel=true 
value="
.param temp=27
.OPTION RSHUNT=1e6
.OPTION CSHUNT=1e-13
.option rseries = 10.0e-0
.options method=gear reltol=1e-3 abstol=1e-6
*.options gmin=1e-10
*.ic V(out)=0

.control
save all 
tran  601p 180n 
meas tran tdelayf TRIG v(inp) VAl=0.6 FALl=1 TARG v(out) VAl=0.6 FALL=1
meas tran tdelayr TRIG v(inp) VAl=0.6 RISE=2 TARG v(out) VAl=0.6 RISE=2
write power_io.raw


.endc
"}
C {devices/launcher.sym} -1290 160 0 0 {name=h5
descr="load waves Ctrl + left click" 
tclcommand="xschem raw_read $netlist_dir/power_io.raw tran"
}
C {vsource.sym} -120 -870 0 0 {name=V6 value="dc 0 ac 0 pulse(0, 1.2, 5n, 50p, 50p, 10n, 20n)" savecurrent=false}
C {lab_pin.sym} -120 -940 1 0 {name=p11 sig_type=std_logic lab=in_a}
C {lab_pin.sym} -490 -460 1 0 {name=p1 sig_type=std_logic lab=in_a}
C {IHP-Open-PDK/ihp-sg13g2/libs.ref/sg13g2_io/xschem/sg13g2_IOPadAnalog.sym} -310 -440 2 0 {name=x17}
C {lab_wire.sym} -100 -440 0 1 {name=p24 sig_type=std_logic lab=START
}
C {lab_wire.sym} -100 -360 0 1 {name=p25 sig_type=std_logic lab=STOP
}
C {GROTDC.sym} 100 -80 0 0 {name=x4
}
C {/home/designer/shared//GRO-TDC/IHP-Open-PDK/ihp-sg13g2/libs.ref/sg13g2_io/xschem/sg13g2_IOPadAnalog.sym} -310 -360 2 0 {name=x2}
C {sg13g2_pr/bondpad.sym} -570 -440 3 1 {name=X12
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {lab_pin.sym} -490 -380 1 0 {name=p12 sig_type=std_logic lab=in_b}
C {sg13g2_pr/bondpad.sym} -570 -360 3 1 {name=X20
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {/home/designer/shared//GRO-TDC/IHP-Open-PDK/ihp-sg13g2/libs.ref/sg13g2_io/xschem/sg13g2_IOPadAnalog.sym} -310 -280 2 0 {name=x21}
C {sg13g2_pr/bondpad.sym} -570 -280 3 1 {name=X22
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {lab_pin.sym} -490 -300 1 0 {name=p13 sig_type=std_logic lab=in_c}
C {lab_wire.sym} -100 -280 0 1 {name=p15 sig_type=std_logic lab=CTRL[0]
}
C {/home/designer/shared//GRO-TDC/IHP-Open-PDK/ihp-sg13g2/libs.ref/sg13g2_io/xschem/sg13g2_IOPadAnalog.sym} 730 -220 2 1 {name=x14}
C {lab_pin.sym} 910 -240 3 1 {name=p16 sig_type=std_logic lab=out_a}
C {sg13g2_pr/bondpad.sym} 990 -220 1 0 {name=X19
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {/home/designer/shared//GRO-TDC/IHP-Open-PDK/ihp-sg13g2/libs.ref/sg13g2_io/xschem/sg13g2_IOPadAnalog.sym} -310 -120 2 0 {name=x23}
C {sg13g2_pr/bondpad.sym} -570 -120 3 1 {name=X24
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {lab_pin.sym} -490 -140 1 0 {name=p17 sig_type=std_logic lab=in_e}
C {/home/designer/shared//GRO-TDC/IHP-Open-PDK/ihp-sg13g2/libs.ref/sg13g2_io/xschem/sg13g2_IOPadAnalog.sym} -310 -200 2 0 {name=x25}
C {sg13g2_pr/bondpad.sym} -570 -200 3 1 {name=X26
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {lab_pin.sym} -490 -220 1 0 {name=p19 sig_type=std_logic lab=in_d}
C {/home/designer/shared//GRO-TDC/IHP-Open-PDK/ihp-sg13g2/libs.ref/sg13g2_io/xschem/sg13g2_IOPadAnalog.sym} -310 -40 2 0 {name=x27}
C {sg13g2_pr/bondpad.sym} -570 -40 3 1 {name=X28
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {lab_pin.sym} -490 -60 1 0 {name=p23 sig_type=std_logic lab=in_f}
C {lab_wire.sym} -100 -120 0 1 {name=p28 sig_type=std_logic lab=CTRL[2]
}
C {lab_wire.sym} 160 -1030 1 0 {name=p18 sig_type=std_logic lab=in_b
}
C {vsource.sym} 160 -870 0 0 {name=V7 value="dc 0 ac 0 pulse(0, 1.2, 0, 50p, 50p, 1n, 0)" savecurrent=false
}
C {vsource.sym} 160 -960 0 0 {name=V12 value="dc 0 ac 0 pulse(0, 1.2, 14n, 50p, 50p, 10n, 20n)" savecurrent=false
}
C {lab_wire.sym} 160 -790 0 0 {name=p30 sig_type=std_logic lab=VSS
}
C {vsource.sym} 440 -870 0 0 {name=V8 value="dc 0 ac 0 pulse(0, 1.2, 190n, 500p, 500p, 5n, 0)" savecurrent=false
}
C {lab_wire.sym} 440 -950 0 1 {name=p31 sig_type=std_logic lab=in_c
}
C {lab_wire.sym} 440 -790 0 0 {name=p32 sig_type=std_logic lab=VSS
}
C {vsource.sym} -200 -870 0 0 {name=V5 value=0 savecurrent=false
}
C {gnd.sym} -200 -810 0 0 {name=l1 lab=GND
}
C {lab_wire.sym} -200 -940 0 0 {name=p33 sig_type=std_logic lab=VSS
}
C {lab_wire.sym} -120 -790 0 0 {name=p34 sig_type=std_logic lab=VSS
}
C {vsource.sym} -120 -670 0 0 {name=V9 value="dc 0 ac 0 pulse(0, 1.2, 190n, 500p, 500p, 5n, 0)" savecurrent=false
}
C {lab_wire.sym} -120 -750 0 1 {name=p35 sig_type=std_logic lab=in_e
}
C {lab_wire.sym} -120 -590 0 0 {name=p36 sig_type=std_logic lab=VSS
}
C {vsource.sym} 160 -670 0 0 {name=V10 value="dc 0 ac 0 pulse(0, 1.2, 190n, 500p, 500p, 5n, 0)" savecurrent=false
}
C {lab_wire.sym} 160 -750 0 1 {name=p37 sig_type=std_logic lab=in_f
}
C {lab_wire.sym} 160 -590 0 0 {name=p38 sig_type=std_logic lab=VSS
}
C {lab_wire.sym} 60 -200 0 0 {name=p39 sig_type=std_logic lab=CTRL[2:0]
}
C {lab_wire.sym} 460 -220 3 1 {name=p27 sig_type=std_logic lab=OUT
}
C {/home/designer/shared/GRO-TDC/IHP-Open-PDK/ihp-sg13g2/libs.ref/sg13g2_io/xschem/sg13g2_IOPadVdd.sym} 100 270 1 0 {name=x29}
C {sg13g2_pr/bondpad.sym} 100 530 2 1 {name=X30
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {lab_pin.sym} 70 470 3 1 {name=p40 sig_type=std_logic lab=IO_vdd}
C {/home/designer/shared/GRO-TDC/IHP-Open-PDK/ihp-sg13g2/libs.ref/sg13g2_io/xschem/sg13g2_IOPadVSS.sym} 180 270 1 0 {name=x31}
C {lab_pin.sym} 150 470 1 0 {name=p41 sig_type=std_logic lab=IO_vss}
C {sg13g2_pr/bondpad.sym} 180 530 2 1 {name=X32
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {/home/designer/shared/GRO-TDC/IHP-Open-PDK/ihp-sg13g2/libs.ref/sg13g2_io/xschem/sg13g2_IOPadIOVdd.sym} 260 270 1 0 {name=x33}
C {/home/designer/shared/GRO-TDC/IHP-Open-PDK/ihp-sg13g2/libs.ref/sg13g2_io/xschem/sg13g2_IOPadIOVss.sym} 340 270 1 0 {name=x34}
C {/home/designer/shared//GRO-TDC/IHP-Open-PDK/ihp-sg13g2/libs.ref/sg13g2_io/xschem/sg13g2_IOPadAnalog.sym} -310 40 2 0 {name=x5}
C {sg13g2_pr/bondpad.sym} -570 40 3 1 {name=X8
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {lab_pin.sym} -490 20 1 0 {name=p5 sig_type=std_logic lab=in_g}
C {lab_wire.sym} -100 -40 0 1 {name=p42 sig_type=std_logic lab=DECLK

}
C {lab_wire.sym} -60 40 0 1 {name=p43 sig_type=std_logic lab=RESET

}
C {lab_pin.sym} 230 470 1 0 {name=p44 sig_type=std_logic lab=IO_iovdd}
C {sg13g2_pr/bondpad.sym} 260 530 2 0 {name=X35
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {lab_pin.sym} 300 470 1 0 {name=p45 sig_type=std_logic lab=IO_iovss}
C {sg13g2_pr/bondpad.sym} 340 530 2 0 {name=X36
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {lab_wire.sym} -100 -200 0 1 {name=p2 sig_type=std_logic lab=CTRL[1]
}
C {vsource.sym} 440 -670 0 0 {name=V11 value="dc 0 ac 0 pulse(0, 1.2, 190n, 500p, 500p, 5n, 0)" savecurrent=false
}
C {lab_wire.sym} 440 -750 0 1 {name=p4 sig_type=std_logic lab=in_g
}
C {lab_wire.sym} 440 -590 0 0 {name=p6 sig_type=std_logic lab=VSS
}
C {devices/launcher.sym} 5085 -1075 0 0 {name=h1
descr="load waves Ctrl + left click" 
tclcommand="xschem raw_read $netlist_dir/tb_TOP_io.raw tran"
}
C {devices/launcher.sym} 5085 -1135 0 0 {name=h2
descr="simulate" 
tclcommand="xschem save; xschem netlist; xschem simulate"
}
C {vsource.sym} 4870 -610 0 0 {name=V13 value="dc 0 ac 0 pulse(0, 1.2, 190n, 500p, 500p, 5n, 0)" savecurrent=false
}
C {lab_wire.sym} 4640 -170 0 0 {name=p3 sig_type=std_logic lab=VSS
}
C {lab_wire.sym} 4870 -680 0 1 {name=p14 sig_type=std_logic lab=RESET_PAD
}
C {lab_wire.sym} 4640 -300 0 1 {name=p20 sig_type=std_logic lab=DECLK
}
C {vsource.sym} 4640 -230 0 0 {name=V14 value="dc 0 ac 0 pulse(0, 1.2, 27n, 500p, 500p, 100n)" savecurrent=false
}
C {lab_wire.sym} 4870 -550 0 0 {name=p49 sig_type=std_logic lab=VSS
}
C {lab_wire.sym} 4640 -550 0 0 {name=p54 sig_type=std_logic lab=VSS
}
C {lab_wire.sym} 4760 -680 0 1 {name=p55 sig_type=std_logic lab=STOP_PAD
}
C {lab_wire.sym} 4640 -680 0 1 {name=p56 sig_type=std_logic lab=START_PAD
}
C {vsource.sym} 4640 -610 0 0 {name=V15 value="dc 0 ac 0 pulse(0, 1.2, 5n, 50p, 50p, 21n)" savecurrent=false
}
C {vsource.sym} 4760 -520 0 0 {name=V16 value="dc 0 ac 0 pulse(0, 1.2, 0, 50p, 50p, 1n, 0)" savecurrent=false
}
C {vsource.sym} 4760 -610 0 0 {name=V17 value="dc 0 ac 0 pulse(0, 1.2, 14n, 50p, 50p, 100n)" savecurrent=false
}
C {lab_wire.sym} 4760 -460 0 0 {name=p60 sig_type=std_logic lab=VSS
}
C {code.sym} 5020 -990 0 0 {name=NGSPICE1 only_toplevel=true 
value="
.param temp=65


.control
save all 
tran 10p 35n
* Sources
let START = v(START)
let STOP = v(STOP)
let DECLK = v(DECLK)
let RESET = v(RESET)

* GRO
let IN0 = v(x2.IN0)
let IN1 = v(x2.IN1)
let IN2 = v(x2.IN2)

* Buffers
let K0 = v(x2.K0)
let K1 = v(x2.K1)
let K2 = v(x2.K2)

* Counters Reg
let D0_0 = v(x2.D0[0])
let D0_1 = v(x2.D0[1])
let D0_2 = v(x2.D0[2])
let D0_3 = v(x2.D0[3])
let D0_4 = v(x2.D0[4])
let D0_5 = v(x2.D0[5])
let D1_0 = v(x2.D1[0])
let D1_1 = v(x2.D1[1])
let D1_2 = v(x2.D1[2])
let D1_3 = v(x2.D1[3])
let D1_4 = v(x2.D1[4])
let D1_5 = v(x2.D1[5])
let D2_0 = v(x2.D2[0])
let D2_1 = v(x2.D2[1])
let D2_2 = v(x2.D2[2])
let D2_3 = v(x2.D2[3])
let D2_4 = v(x2.D2[4])
let D2_5 = v(x2.D2[5])

* FA
let S1_0 = v(x2.S1[0])
let S1_1 = v(x2.S1[1])
let S1_2 = v(x2.S1[2])
let S1_3 = v(x2.S1[3])
let S1_4 = v(x2.S1[4])
let S1_5 = v(x2.S1[5])
let COUT1 = v(x2.COUT1)
let S2_0 = v(x2.S2[0])
let S2_1 = v(x2.S2[1])
let S2_2 = v(x2.S2[2])
let S2_3 = v(x2.S2[3])
let S2_4 = v(x2.S2[4])
let S2_5 = v(x2.S2[5])
let S2_6 = v(x2.S2[6])
let COUT2 = v(x2.COUT2)

* FA Regs
let ADDER_0 = v(x2.ADDER[0])
let ADDER_1 = v(x2.ADDER[1])
let ADDER_2 = v(x2.ADDER[2])
let ADDER_3 = v(x2.ADDER[3])
let ADDER_4 = v(x2.ADDER[4])
let ADDER_5 = v(x2.ADDER[5])
let ADDER_6 = v(x2.ADDER[6])
let ADDER_7 = v(x2.ADDER[7])

write tb_TOP_io.raw
wrdata tb_TOP_io.raw time START STOP DECLK RESET IN0 IN1 IN2 K0 K1 K2 D0_0 D0_1 D0_2 D0_3 D0_4 D0_5 D1_0 D1_1 D1_2 D1_3 D1_4 D1_5 D2_0 D2_1 D2_2 D2_3 D2_4 D2_5 S1_0 S1_1 S1_2 S1_3 S1_4 S1_5 COUT1 S2_0 S2_1 S2_2 S2_3 S2_4 S2_5 S2_6 COUT2 ADDER_0 ADDER_1 ADDER_2 ADDER_3 ADDER_4 ADDER_5 ADDER_6  ADDER_7


*set appendwrite

.endc
"
}
C {Counters_6bits.sym} 5790 -420 0 0 {name=x1
}
C {Counters_regs_6bits.sym} 6230 -390 0 0 {name=x6
}
C {Counter_FA_6bits.sym} 5430 -210 0 0 {name=x7
}
C {Counter_FA_7bits.sym} 5630 -130 0 0 {name=x3
}
C {lab_wire.sym} 5830 -570 3 0 {name=p21 sig_type=std_logic lab=K1
}
C {lab_wire.sym} 5810 -590 3 0 {name=p22 sig_type=std_logic lab=K0
}
C {lab_wire.sym} 5850 -550 3 0 {name=p26 sig_type=std_logic lab=K2
}
C {lab_wire.sym} 5870 -520 3 0 {name=p29 sig_type=std_logic lab=DECLK
}
C {lab_wire.sym} 6290 -540 3 0 {name=p46 sig_type=std_logic lab=DECLK
}
C {lab_wire.sym} 6310 -520 3 0 {name=p47 sig_type=std_logic lab=RESET
}
C {lab_wire.sym} 5870 -350 0 0 {name=p48 sig_type=std_logic lab=COUT1,S1[5:0]
}
C {lab_wire.sym} 6630 -590 0 1 {name=p50 sig_type=std_logic lab=D0[5:0]
}
C {lab_wire.sym} 6610 -570 0 1 {name=p51 sig_type=std_logic lab=D1[5:0]
}
C {lab_wire.sym} 6590 -550 0 1 {name=p52 sig_type=std_logic lab=D2[5:0]
}
C {lab_wire.sym} 5410 -350 0 0 {name=p53 sig_type=std_logic lab=D0[5:0]
}
C {lab_wire.sym} 5410 -300 0 0 {name=p57 sig_type=std_logic lab=D1[5:0]
}
C {lab_wire.sym} 5870 -300 0 0 {name=p58 sig_type=std_logic lab=VSS,D2[5:0]
}
C {lab_wire.sym} 5410 -250 0 0 {name=p59 sig_type=std_logic lab=VSS
}
C {lab_wire.sym} 5870 -250 0 0 {name=p61 sig_type=std_logic lab=VSS
}
C {lab_wire.sym} 5710 -320 0 1 {name=p62 sig_type=std_logic lab=S1[5:0]
}
C {lab_wire.sym} 5710 -280 0 1 {name=p63 sig_type=std_logic lab=COUT1
}
C {lab_wire.sym} 6170 -280 0 1 {name=p64 sig_type=std_logic lab=COUT2
}
C {lab_wire.sym} 6290 -300 3 0 {name=p65 sig_type=std_logic lab=DECLK2
}
C {lab_wire.sym} 6310 -260 3 0 {name=p66 sig_type=std_logic lab=RESET
}
C {Counters__FA_regs_7bits.sym} 6290 -180 0 0 {name=x9
}
C {lab_wire.sym} 6610 -300 0 1 {name=p67 sig_type=std_logic lab=ADDER[7:0]
}
C {lab_wire.sym} 6170 -320 0 1 {name=p68 sig_type=std_logic lab=S2[6:0]
}
C {lab_wire.sym} 6290 -340 0 0 {name=p69 sig_type=std_logic lab=COUT2,S2[6:0]
}
C {SR_Latch.sym} 6060 -850 0 0 {name=x10}
C {lab_wire.sym} 6040 -960 0 0 {name=p70 sig_type=std_logic lab=START
}
C {lab_wire.sym} 6040 -920 0 0 {name=p71 sig_type=std_logic lab=STOP
}
C {lab_wire.sym} 6260 -960 0 0 {name=p72 sig_type=std_logic lab=EN
}
C {GRO.sym} 6290 -740 0 0 {name=x11
}
C {lab_wire.sym} 6450 -730 0 0 {name=p73 sig_type=std_logic lab=IN0
}
C {lab_wire.sym} 6570 -730 0 0 {name=p74 sig_type=std_logic lab=IN1
}
C {lab_wire.sym} 6690 -730 0 0 {name=p75 sig_type=std_logic lab=IN2
}
C {Modi_Buffers.sym} 5350 -390 0 0 {name=x13
}
C {lab_wire.sym} 5720 -610 3 1 {name=p76 sig_type=std_logic lab=K0
}
C {lab_wire.sym} 5720 -570 3 1 {name=p77 sig_type=std_logic lab=K1
}
C {lab_wire.sym} 5720 -530 3 1 {name=p78 sig_type=std_logic lab=K2
}
C {lab_wire.sym} 5420 -610 1 0 {name=p79 sig_type=std_logic lab=IN0
}
C {lab_wire.sym} 5420 -570 1 0 {name=p80 sig_type=std_logic lab=IN1
}
C {lab_wire.sym} 5420 -530 1 0 {name=p81 sig_type=std_logic lab=IN2
}
C {lab_wire.sym} 6190 -620 0 1 {name=p82 sig_type=std_logic lab=C0_B[5:0]
}
C {lab_wire.sym} 6210 -600 0 1 {name=p83 sig_type=std_logic lab=C1_B[5:0]
}
C {lab_wire.sym} 6230 -580 0 1 {name=p84 sig_type=std_logic lab=C2_B[5:0]
}
C {lab_wire.sym} 4720 -170 0 0 {name=p85 sig_type=std_logic lab=VSS
}
C {lab_wire.sym} 4720 -300 0 1 {name=p86 sig_type=std_logic lab=DECLK2
}
C {vsource.sym} 4720 -230 0 0 {name=V18 value="dc 0 ac 0 pulse(0, 1.2, 30n, 500p, 500p, 100n)" savecurrent=false
}
C {devices/code_shown.sym} 4630 -1200 0 0 {name=MODEL1 only_toplevel=true
format="tcleval( @value )"
value="
.lib cornerMOSlv.lib mos_tt
.lib cornerMOShv.lib mos_tt
.lib cornerRES.lib res_typ
.include diodes.lib
.include sg13g2_bondpad.lib
"}
C {sg13g2_IOPadAnalog.sym} 5800 620 0 1 {name=x15}
C {sg13g2_pr/bondpad.sym} 5540 620 3 1 {name=X16
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {lab_pin.sym} 6040 620 0 1 {name=p87 sig_type=std_logic lab=START}
C {lab_pin.sym} 5620 600 2 0 {name=p88 sig_type=std_logic lab=START_PAD}
C {vsource.sym} 4780 -920 0 0 {name=V19 value=1.2}
C {gnd.sym} 4780 -890 0 0 {name=l15 lab=GND}
C {lab_pin.sym} 4780 -960 1 0 {name=p90 sig_type=std_logic lab=IO_vdd}
C {vsource.sym} 4840 -920 0 0 {name=V20 value=3.3
}
C {gnd.sym} 4840 -890 0 0 {name=l16 lab=GND}
C {lab_pin.sym} 4840 -960 1 0 {name=p91 sig_type=std_logic lab=IO_iovdd}
C {vsource.sym} 4700 -920 0 0 {name=V21 value=0 savecurrent=false}
C {gnd.sym} 4700 -890 0 0 {name=l17 lab=GND}
C {lab_pin.sym} 4700 -960 1 0 {name=p92 sig_type=std_logic lab=IO_vss}
C {vsource.sym} 4640 -920 0 0 {name=V22 value=0 savecurrent=false}
C {gnd.sym} 4640 -890 0 0 {name=l18 lab=GND}
C {lab_pin.sym} 4640 -960 1 0 {name=p93 sig_type=std_logic lab=IO_iovss}
C {sg13g2_pr/sub.sym} 4640 -800 0 0 {name=l21 lab=sub!}
C {gnd.sym} 4740 -800 0 0 {name=l22 lab=GND}
C {vsource.sym} 4690 -810 1 0 {name=V23 value=0 savecurrent=false}
C {lab_pin.sym} 6130 1570 3 1 {name=p89 sig_type=std_logic lab=IO_vdd}
C {lab_pin.sym} 6220 1570 1 0 {name=p94 sig_type=std_logic lab=IO_vss}
C {sg13g2_IOPadVSS.sym} 6250 1390 3 1 {name=x18}
C {sg13g2_IOPadVdd.sym} 6170 1390 3 1 {name=x37}
C {sg13g2_pr/bondpad.sym} 6170 1650 2 1 {name=X38
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 6250 1650 2 1 {name=X39
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {lab_pin.sym} 6130 290 1 0 {name=p95 sig_type=std_logic lab=IO_iovdd}
C {lab_pin.sym} 6200 290 1 0 {name=p96 sig_type=std_logic lab=IO_iovss}
C {sg13g2_IOPadIOVdd.sym} 6160 410 3 0 {name=x40}
C {sg13g2_IOPadIOVss.sym} 6240 410 3 0 {name=x41}
C {sg13g2_pr/bondpad.sym} 6240 190 0 0 {name=X42
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 6160 190 0 0 {name=X43
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_IOPadAnalog.sym} 6610 700 2 1 {name=x44}
C {sg13g2_pr/bondpad.sym} 6870 700 1 1 {name=X45
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {lab_pin.sym} 6370 700 2 1 {name=p97 sig_type=std_logic lab=ADDER[1]}
C {lab_pin.sym} 6790 720 3 0 {name=p98 sig_type=std_logic lab=in_a}
C {sg13g2_IOPadAnalog.sym} 5800 700 0 1 {name=x46}
C {sg13g2_pr/bondpad.sym} 5540 700 3 1 {name=X47
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {lab_pin.sym} 6040 700 0 1 {name=p99 sig_type=std_logic lab=STOP}
C {lab_pin.sym} 5620 680 2 0 {name=p100 sig_type=std_logic lab=STOP_PAD}
C {sg13g2_IOPadAnalog.sym} 5800 780 0 1 {name=x48}
C {sg13g2_pr/bondpad.sym} 5540 780 3 1 {name=X49
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {lab_pin.sym} 6040 780 0 1 {name=p101 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 5620 760 2 0 {name=p102 sig_type=std_logic lab=RESET_PAD}
C {lab_pin.sym} 5570 -690 2 0 {name=p103 sig_type=std_logic lab=IO_vdd}
C {lab_pin.sym} 6150 -1020 2 0 {name=p104 sig_type=std_logic lab=IO_vdd}
C {lab_pin.sym} 6350 -1030 2 0 {name=p105 sig_type=std_logic lab=IO_vdd}
C {lab_pin.sym} 6010 -680 2 0 {name=p106 sig_type=std_logic lab=IO_vdd}
C {lab_pin.sym} 6450 -680 2 0 {name=p107 sig_type=std_logic lab=IO_vdd}
C {lab_pin.sym} 5570 -410 2 0 {name=p108 sig_type=std_logic lab=IO_vdd}
C {lab_pin.sym} 6010 -410 2 0 {name=p109 sig_type=std_logic lab=IO_vdd}
C {lab_pin.sym} 6450 -410 2 0 {name=p110 sig_type=std_logic lab=IO_vdd}
C {lab_pin.sym} 5570 -450 2 0 {name=p111 sig_type=std_logic lab=IO_vss}
C {lab_pin.sym} 6010 -460 2 0 {name=p112 sig_type=std_logic lab=IO_vss}
C {lab_pin.sym} 6450 -460 2 0 {name=p113 sig_type=std_logic lab=IO_vss}
C {lab_pin.sym} 5570 -190 2 0 {name=p114 sig_type=std_logic lab=IO_vss}
C {lab_pin.sym} 6010 -190 2 0 {name=p115 sig_type=std_logic lab=IO_vss}
C {lab_pin.sym} 6450 -190 2 0 {name=p116 sig_type=std_logic lab=IO_vss}
C {lab_pin.sym} 6150 -860 2 0 {name=p117 sig_type=std_logic lab=IO_vss}
C {lab_pin.sym} 6350 -730 2 1 {name=p118 sig_type=std_logic lab=IO_vss}
C {sg13g2_IOPadAnalog.sym} 6610 620 2 1 {name=x50}
C {sg13g2_pr/bondpad.sym} 6870 620 1 1 {name=X51
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {lab_pin.sym} 6370 620 2 1 {name=p119 sig_type=std_logic lab=ADDER[0]}
C {lab_pin.sym} 6790 640 3 0 {name=p120 sig_type=std_logic lab=in_a}
C {sg13g2_IOPadAnalog.sym} 6610 780 2 1 {name=x52}
C {sg13g2_pr/bondpad.sym} 6870 780 1 1 {name=X53
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {lab_pin.sym} 6370 780 2 1 {name=p121 sig_type=std_logic lab=ADDER[2]}
C {lab_pin.sym} 6790 800 3 0 {name=p122 sig_type=std_logic lab=in_a}
C {sg13g2_IOPadAnalog.sym} 6610 860 2 1 {name=x54}
C {sg13g2_pr/bondpad.sym} 6870 860 1 1 {name=X55
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {lab_pin.sym} 6370 860 2 1 {name=p123 sig_type=std_logic lab=ADDER[3]}
C {lab_pin.sym} 6790 880 3 0 {name=p124 sig_type=std_logic lab=in_a}
C {sg13g2_IOPadAnalog.sym} 6610 940 2 1 {name=x56}
C {sg13g2_pr/bondpad.sym} 6870 940 1 1 {name=X57
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {lab_pin.sym} 6370 940 2 1 {name=p125 sig_type=std_logic lab=ADDER[4]}
C {lab_pin.sym} 6790 960 3 0 {name=p126 sig_type=std_logic lab=in_a}
C {sg13g2_IOPadAnalog.sym} 6610 1100 2 1 {name=x58}
C {sg13g2_pr/bondpad.sym} 6870 1100 1 1 {name=X59
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {lab_pin.sym} 6370 1100 2 1 {name=p127 sig_type=std_logic lab=ADDER[6]}
C {lab_pin.sym} 6790 1120 3 0 {name=p128 sig_type=std_logic lab=in_a}
C {sg13g2_IOPadAnalog.sym} 6610 1020 2 1 {name=x60}
C {sg13g2_pr/bondpad.sym} 6870 1020 1 1 {name=X61
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {lab_pin.sym} 6370 1020 2 1 {name=p129 sig_type=std_logic lab=ADDER[5]}
C {lab_pin.sym} 6790 1040 3 0 {name=p130 sig_type=std_logic lab=in_a}
C {sg13g2_IOPadAnalog.sym} 6610 1180 2 1 {name=x62}
C {sg13g2_pr/bondpad.sym} 6870 1180 1 1 {name=X63
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {lab_pin.sym} 6370 1180 2 1 {name=p131 sig_type=std_logic lab=ADDER[7]}
C {lab_pin.sym} 6790 1200 3 0 {name=p132 sig_type=std_logic lab=in_a}
